Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: f722d73c-6623-4cfd-889b-6db73d44a980.ifc
Time: 2026-08-11T16:27:32
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Feniks Elektrisch 90 600 x 1200mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAC5iBUAGAAAA4OoCAAWxXwAAPHsBAHQGAAC06gIA4uoCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIApOwCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAC5iBUAGAAAA4OoCAAWxXwAAPHsBAHQGAAC06gIA4uoCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIApOwCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 32.32.11; lengte: 1180 mm; inbouwhoogte: 240 mm; inbouwlengte: 1200 mm; U-waarde: 0,93 w/m²·k; breedte: 580 mm; max. belasting: 200 kg; NAA.K.T: samengesteld_product_generiek; bediening: elektrisch; theoretische levensduur: 50; serie: Schaartrap Feniks Elektrisch 90; inbouwbreedte: 600 mm; merk: Storax; beweegbaar: True; brandwerendheid EI2: 90 mm; omranding: staal; luik: staal; trap: schaarladder Storax - Schaarladder 200mm
